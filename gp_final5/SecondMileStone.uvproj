# Keil uVision project SecondMileStone.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Dio_test
  c flags: Optim=1
  c include: .\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Src
    ./: startup_TM4C123.s
    ./Src/: main.c SYSTICK_program.c LCD_program.c DIO_program.c GPS_Calculations.c PFInterruptInit.c EEPROM.c UART.c
  group Include
    ./Include/: BIT_MATH.h STD_TYPES.h SYSTICK_interface.h LCD_config.h LCD_interface.h DIO_interface.h DIO_config.h tm4c123gh6pm.h GPS_Calculations.h PFInterruptInit.h EEPROM.h Header_Project.h UART.h
